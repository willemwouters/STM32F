# IAR project WPS_EasyLink.ewp, settings and files
configuration EMW3162_Debug (ARM)
  General.OGChipSelectEditMenu: STM32F205ZG ST STM32F205ZG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; EMW3162
  ICCARM.CCIncludePath2: ..\..\..\Library; ..\..\..\STM32F2xx_StdPeriph_Driver\inc; ..\..\..\Demo3_WPS_EasyLink; ..\..\..\HAL
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: WiFi_Link.srec
  ILINK.IlinkOutputFile: WPS_EasyLink.out
  ILINK.IlinkIcfFile: mxchipWNet.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration EMW3161_Debug (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F205RG ST STM32F205RG
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; EMW3161
  ICCARM.CCIncludePath2: ..\..\..\Library; ..\..\..\STM32F2xx_StdPeriph_Driver\inc; ..\..\..\Demos\Demo3_WPS_EasyLink; ..\..\..\HAL
  OBJCOPY.OOCOutputFile: WPS_EasyLink.srec
  group Application
    ../../../Demos/Demo3_WPS_EasyLink/: main.c menu.c stm32f2xx_it.c
  group HAL
    ../../../HAL/: uart.c
  group Library
    ../../../Library/: besl.ARM_Cortex_M3.release.a mico_config.c mxchipWNet_3161.a mxchipWNet_3162.a
  group platform
    ../../../HAL/: platform.c system_stm32f2xx.c
  group startup
    ./: startup_stm32f2xx.s
  group STM32_HAL_LIB
    ../../../STM32F2xx_StdPeriph_Driver/src/: misc.c stm32f2xx_adc.c stm32f2xx_can.c stm32f2xx_crc.c stm32f2xx_cryp.c stm32f2xx_cryp_aes.c stm32f2xx_cryp_des.c stm32f2xx_cryp_tdes.c stm32f2xx_dac.c stm32f2xx_dbgmcu.c stm32f2xx_dcmi.c stm32f2xx_dma.c stm32f2xx_exti.c stm32f2xx_flash.c stm32f2xx_fsmc.c stm32f2xx_gpio.c stm32f2xx_hash.c stm32f2xx_hash_md5.c stm32f2xx_hash_sha1.c stm32f2xx_i2c.c stm32f2xx_iwdg.c stm32f2xx_pwr.c stm32f2xx_rcc.c stm32f2xx_rng.c stm32f2xx_rtc.c stm32f2xx_sdio.c stm32f2xx_spi.c stm32f2xx_syscfg.c stm32f2xx_tim.c stm32f2xx_usart.c stm32f2xx_wwdg.c
