# Keil uVision project TCP_UDP_ECHO.uvproj, settings and files
target TCP_UDP_ECHO@EMW3162 (ARM-ADS)
  device: STM32F215RG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: TCP_ECHO
  AfterMake: fromelf --bin .\Obj\TCP_ECHO.axf --output ..\Output\TCP_ECHO.bin
  c flags: Optim=1
  c define: EMW3162 USE_STDPERIPH_DRIVER
  c include: ..\..\Demo2_TCP_ECHO;..\..\..\Library;..\..\..\STM32F2xx_StdPeriph_Driver\inc;..\..\..\HAL
  library: MicroLIB
  memory RVCT4: ROM 0x800c000 size 0xf8000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group startup
    ./startup/: startup_stm32f2xx.s
  group mxchipWNet
    ../../../Library/: mxchipWNet_3162.lib mxchipWNet_3161.lib
  group platform
    ../../../HAL/: system_stm32f2xx.c platform.c
  group Application
    ../../../Demos/Demo2_TCP_UDP_ECHO/: main.c stm32f2xx_it.c
  group STM32_HAL_LIB
    ../../../STM32F2xx_StdPeriph_Driver/src/: misc.c stm32f2xx_adc.c stm32f2xx_dma.c stm32f2xx_exti.c stm32f2xx_flash.c stm32f2xx_gpio.c stm32f2xx_i2c.c stm32f2xx_pwr.c stm32f2xx_rcc.c stm32f2xx_rtc.c stm32f2xx_sdio.c stm32f2xx_spi.c stm32f2xx_syscfg.c stm32f2xx_tim.c stm32f2xx_usart.c stm32f2xx_rng.c
target TCP_UDP_ECHO@EMW3161 (ARM-ADS)
  device: STM32F215RG STMicroelectronics
  cpu: as above
  output: TCP_ECHO
  AfterMake: as above
  c flags: Optim=1
  c define: EMW3161 USE_STDPERIPH_DRIVER
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x800c000 size 0xf8000
  memory RVCT9: RAM 0x20000000 size 0x20000
