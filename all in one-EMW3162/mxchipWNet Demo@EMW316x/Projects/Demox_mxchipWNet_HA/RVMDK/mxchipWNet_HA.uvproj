# Keil uVision project mxchipWNet_HA.uvproj, settings and files
target mxchipWNet@EMW3162 (ARM-ADS)
  device: STM32F215RG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: mxchipWNet_HA +hex
  AfterMake: fromelf --bin .\Obj\mxchipWNet_HA.axf --output ..\Output\mxchipWNet_HA.bin
  c flags: Optim=1
  c define: mxchipWNet_HA EMW3162 USE_STDPERIPH_DRIVER
  c include: ..\..\..\Library;..\..\..\STM32F2xx_StdPeriph_Driver\inc;..\..\..\HAL;..\..\..\Demos\Demox_mxchipWNet_HA
  library: MicroLIB
  memory RVCT4: ROM 0x800c000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group startup
    ./startup/: startup_stm32f2xx.s
  group mxchipWNet
    ../../../Library/: mxchipWNet_3162.lib mxchipWNet_3161.lib
  group Application
    ../../../Demos/Demox_mxchipWNet_HA/: main.c mxchipWNet_HA.c stm32f2xx_it.c user_misc.c
  group platform
    ../../../HAL/: system_stm32f2xx.c hal_misc.c uart.c flash_if.c
  group STM32_HAL_LIB
    ../../../STM32F2xx_StdPeriph_Driver/src/: misc.c stm32f2xx_adc.c stm32f2xx_dma.c stm32f2xx_exti.c stm32f2xx_flash.c stm32f2xx_gpio.c stm32f2xx_i2c.c stm32f2xx_pwr.c stm32f2xx_rcc.c stm32f2xx_rtc.c stm32f2xx_sdio.c stm32f2xx_spi.c stm32f2xx_syscfg.c stm32f2xx_tim.c stm32f2xx_usart.c stm32f2xx_rng.c
target mxchipWNet@EMW3161 (ARM-ADS)
  device: STM32F215RG STMicroelectronics
  cpu: as above
  output: mxchipWNet_HA +hex
  AfterMake: as above
  c flags: Optim=1
  c define: mxchipWNet_HA EMW3161 USE_STDPERIPH_DRIVER
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x800c000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
