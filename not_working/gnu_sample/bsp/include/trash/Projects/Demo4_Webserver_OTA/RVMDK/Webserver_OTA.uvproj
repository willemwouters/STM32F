# Keil uVision project Webserver_OTA.uvproj, settings and files
target Webserver_OTA@EMW3162 (ARM-ADS)
  device: STM32F215RG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: Webserver_OTA
  AfterMake: fromelf --bin .\Obj\Webserver_OTA.axf --output ..\Output\Webserver_OTA.bin
  c flags: Optim=1
  c define: EMW3162 USE_STDPERIPH_DRIVER
  c include: ..\..\..\Demos\Demo4_Webserver_OTA;..\..\..\Library;..\..\..\STM32F2xx_StdPeriph_Driver\inc;..\..\..\HAL
  library: MicroLIB
  memory RVCT4: ROM 0x800c000 size 0xf8000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group startup
    ./startup/: startup_stm32f2xx.s
  group mxchipWNet
    ../../../Library/: mxchipWNet_3162.lib mxchipWNet_3161.lib
  group platform
    ../../../HAL/: system_stm32f2xx.c platform.c flash_if.c
  group Application
    ../../../Demos/Demo4_Webserver_OTA/: base64.c flash_configurations.c http_process.c main.c stm32f2xx_it.c web_data.c
  group STM32_HAL_LIB
    ../../../STM32F2xx_StdPeriph_Driver/src/: misc.c stm32f2xx_adc.c stm32f2xx_dma.c stm32f2xx_exti.c stm32f2xx_flash.c stm32f2xx_gpio.c stm32f2xx_pwr.c stm32f2xx_rcc.c stm32f2xx_rtc.c stm32f2xx_sdio.c stm32f2xx_spi.c stm32f2xx_syscfg.c stm32f2xx_tim.c stm32f2xx_usart.c stm32f2xx_i2c.c stm32f2xx_rng.c
target Webserver_OTA@EMW3161 (ARM-ADS)
  device: STM32F205RG STMicroelectronics
  cpu: as above
  output: Webserver_OTA
  AfterMake: as above
  c flags: Optim=1
  c define: EMW3161 USE_STDPERIPH_DRIVER
  c include: ..\..\..\Library;..\..\..\STM32F2xx_StdPeriph_Driver\inc;..\..\..\HAL;..\..\..\Demos\Demo4_Webserver_OTA
  library: MicroLIB
  memory RVCT4: ROM 0x800c000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
